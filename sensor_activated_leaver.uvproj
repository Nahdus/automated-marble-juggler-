# Keil uVision project sensor_activated_leaver.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: sensor_activated_leaver
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: sensor_activated_leaver.asm
